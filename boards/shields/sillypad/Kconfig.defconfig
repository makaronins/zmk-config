## boards/shields/sillypad/Kconfig.defconfig
```kconfig
if SHIELD_SILLYPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "sillypad"

endif
```
